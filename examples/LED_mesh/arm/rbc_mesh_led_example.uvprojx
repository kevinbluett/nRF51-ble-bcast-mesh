# Keil uVision project rbc_mesh_led_example.uvprojx, settings and files
target nRF51822 xxAA (ARM-ADS)
  device: nRF51822_xxAA Nordic Semiconductor
  pack: NordicSemiconductor.nRF_DeviceFamilyPack.1.1.4
  cpu: IROM(0x00000000,0x40000) IRAM(0x20000000,0x4000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: rbc_mesh_led_pca10001 +hex
  c flags: Optim=4 uC99=1 wLevel=2
  c define: BOARD_PCA10000 NRF51 BLE_STACK_SUPPORT_REQD BLE_DFU_APP_SUPPORT PSTORAGE_RAW_MODE_ENABLE SOFTDEVICE_PRESENT S110
  c include: ..\include;..\..\..\rbc_mesh;..\..\..\rbc_mesh\include;..\arm
  library: MicroLIB
  memory RVCT4: ROM 0x16000 size 0x29000
  memory RVCT9: RAM 0x20002000 size 0x6000
  group app
    ../: main.c led_config.c
    ./: nrf_adv_conn.c
  group rbc_mesh
    ../../../rbc_mesh/src/: radio_control.c rbc_mesh.c timer_control.c timeslot_handler.c trickle.c mesh_srv.c transport_control.c
  group dfu_service
    ../../../../../../Downloads/nRF51_SDK_7.1.0_372d17a/examples/dfu/bootloader/: dfu_ble_svc.c
  group mesh_dfu
    ../: mesh_dfu.c
  group ::Device
    RTE/Device/nRF51822_xxAA/: arm_startup_nrf51.s system_nrf51.c
  group ::nRF_BLE
    C:/Keil_v5/ARM/PACK/NordicSemiconductor/nRF_BLE/1.1.1/common/: ble_srv_common.c
    C:/Keil_v5/ARM/PACK/NordicSemiconductor/nRF_BLE/1.1.1/device_manager/: device_manager_peripheral.c
    RTE/nRF_BLE/nRF51822_xxAA/: ble_advdata.c ble_advdata.h ble_conn_params.c ble_conn_params.h device_manager_cnfg.h
  group ::nRF_Drivers
    C:/Keil_v5/ARM/PACK/NordicSemiconductor/nRF_Drivers/1.2.1/hal/: nrf_delay.c
    RTE/nRF_Drivers/nRF51822_xxAA/: pstorage.c pstorage.h pstorage_platform.h simple_uart.c simple_uart.h
  group ::nRF_Libraries
    C:/Keil_v5/ARM/PACK/NordicSemiconductor/nRF_Libraries/1.1.1/bootloader_dfu/: bootloader_util_arm.c bootloader_settings_arm.c
    RTE/nRF_Libraries/nRF51822_xxAA/: app_error.c app_error.h app_gpiote.c app_gpiote.h app_scheduler.c app_scheduler.h app_timer.c app_timer.h app_trace.h crc16.c crc16.h dfu_types.h hci_mem_pool.c hci_mem_pool_internal.h nrf_assert.c nrf_assert.h
  group ::nRF_SoftDevice
    RTE/nRF_SoftDevice/nRF51822_xxAA/: softdevice_handler.c
software components: CMSIS:CORE 3.40.0, Board Support:bsp 7.2.0, Device:Startup 1.0.1, nRF_BLE:BLE_Modules:ble_advdata 1.1.1, nRF_BLE:BLE_Modules:ble_common 1.1.1, nRF_BLE:BLE_Modules:ble_conn_params 1.1.1, nRF_BLE:BLE_Modules:ble_service_common 1.1.1, nRF_BLE:BLE_Modules:device_manager 1.1.1, nRF_Drivers:nrf_delay 1.2.1, nRF_Drivers:nrf_error 1.2.1, nRF_Drivers:nrf_gpio 1.2.1, nRF_Drivers:pstorage 1.2.1, nRF_Drivers:simple_uart 1.2.1, nRF_Libraries:DFU:dfu_bootloader_settings 1.1.1, nRF_Libraries:DFU:dfu_bootloader_util 1.1.1, nRF_Libraries:app_error 1.1.1, nRF_Libraries:app_gpiote 1.1.1, nRF_Libraries:app_scheduler 1.1.1, nRF_Libraries:app_timer 1.1.1, nRF_Libraries:app_trace 1.1.1, nRF_Libraries:app_util 1.1.1, nRF_Libraries:crc16 1.1.1, nRF_Libraries:hci_mem_pool 1.1.1, nRF_Libraries:nrf_assert 1.1.1, nRF_SoftDevice:Internal:sd_common 1.1.1, nRF_SoftDevice:Internal:softdevice_present 1.1.1, nRF_SoftDevice:s110 7.1.0-3
